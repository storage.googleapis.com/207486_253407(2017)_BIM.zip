Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-23T10:48:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:48:52 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{C78035D9-DE67-4159-9678-5CC8B1AFF5C6}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:48:52 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:48:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:48:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 253407 Shower rail, 253407(2017):253407 Shower rail:416195
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - Diameter: 22 mm; NominalDepth: 103.406 mm; NominalHeight: 760 mm; NominalWidth: 67.4 mm; Pipe Length: 720 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 253407(2017); ConvergoRefNr: 0087-1909-0097-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_97_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 23/07/2019
Type - Green Building Properties(Type) - Customs Code: 74182000; EAN Number: 6414150086076; LVI Number: 6510229; NRF Number: 4205159; RSK Number: 8284748; VVS Number: 737596004
Type - Identity Data(Type) - Catalog Drawing URL: http://static.oras.com/catdrw/253407; FDV Document URL: http://www.oras.com/datasheet/253407/en/fdv; Group: Shower accessories; Long Marketing: Oras Hydractiva shower rail including adjustable installation elements and slider for hand shower. Max. distance between installation elements 740 mm.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;POL;RUS;EST;LTU;LVA;UKR; Model: 253407 Shower rail; Name_en: 253407 Shower rail; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: n/a; Package Weight: 0.480 kg; Product Code: 253407; Product Datasheet: http://www.oras.com/datasheet/253407/en; Product Family: Oras Hydractiva; Product Image URL: http://static.oras.com/image/253407; Product URL: http://static.oras.com/253407; Type Name: 253407 Shower rail
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Installation and Maintenance: http://static.oras.com/manual/253407; Spare Parts: http://static.oras.com/sp/253407
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 253407(2017); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 253407; Name: 253407 Shower rail; ReplacementCost: n/a; Shape: Sculptured; Size: 65x105x760 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 253407; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 253407 Shower rail
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.136697 m2; Volume: 0.00529161 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 253407(2017): 253407 Shower rail; Family and Type: 253407(2017): 253407 Shower rail; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 253407(2017): 253407 Shower rail; Type Id: 253407(2017): 253407 Shower rail; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
